# IAR project Project_Feed_Shrimp_ver2.ewp, settings and files
configuration Project_Feed_Shrimp_ver2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RC ST STM32L151RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\user_eventdriven; ..\user_component\user_lcd\lcd_16x2; ..\user_app\user_app_button; ..\user_app\user_app_comm; ..\user_app\user_app_lcd; ..\user_app\user_app_menu_display; ..\user_app\user_app_relay; ..\user_app\user_convert_variable; ..\user_util; ..\user_component\user_mem; ..\user_component\user_mem\user_internal_mem; ..\user_timer; ..\user_queue; ..\user_app\user_app_feed_shrimp
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Feed_Shrimp_ver2.hex
  ILINK.IlinkOutputFile: Project_Feed_Shrimp_ver2.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c iwdg.c rtc.c tim.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_iwdg.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
  group user_app/user_app_button
    ../user_app/user_app_button/: user_app_button.c user_app_button.h
  group user_app/user_app_comm
    ../user_app/user_app_comm/: user_app_comm.c user_app_comm.h
  group user_app/user_app_feed_shrimp
    ../user_app/user_app_feed_shrimp/: user_app_feed_shrimp.c user_app_feed_shrimp.h
  group user_app/user_app_lcd
    ../user_app/user_app_lcd/: user_app_lcd.c user_app_lcd.h
  group user_app/user_app_menu_display
    ../user_app/user_app_menu_display/: user_app_menu_display.c user_app_menu_display.h
  group user_app/user_app_relay
    ../user_app/user_app_relay/: user_app_relay.c user_app_relay.h
  group user_app/user_convert_variable
    ../user_app/user_convert_variable/: convert_variable.c convert_variable.h
  group user_component/user_lcd/lcd_16x2
    ../user_component/user_lcd/lcd_16x2/: CLCD.c CLCD.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_string.c user_string.h
